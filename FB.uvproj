# Keil uVision project FB.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\fireSensor;.\main;.\motor;.\trace
  group Source Group 1
    ./: STARTUP.A51
  group main
    ./main/: main.c
  group motor
    ./motor/: motor.c motor.h
  group trace
    ./trace/: trace.c trace.h
  group firesensor
    ./fireSensor/: firesensor.h firesensor.c
